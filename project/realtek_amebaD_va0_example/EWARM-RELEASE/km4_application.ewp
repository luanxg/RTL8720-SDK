# IAR project km4_application.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: CONFIG_PLATFORM_8721D; __FPU_PRESENT; CONFIG_USE_MBEDTLS_ROM_ALG; CONFIG_FUNCION_O0_OPTIMIZE; DM_ODM_SUPPORT_TYPE=32
  ICCARM.IExtraOptions: --no_path_in_file_macros; --cmse
  ICCARM.CCIncludePath2: ..\..\..\component\os\; ..\..\..\component\os\freertos; ..\..\..\component\os\freertos\freertos_v8.1.2\Source\include\; ..\..\..\component\os\freertos\freertos_v8.1.2\Source\portable\IAR\ARM_CM4F\; ..\..\..\component\soc\realtek\amebad\cmsis\; ..\..\..\component\soc\realtek\amebad\cmsis\device; ..\..\..\component\soc\realtek\amebad\fwlib\include; ..\..\..\component\soc\realtek\amebad\fwlib\rom_map_hp; ..\..\..\component\soc\realtek\amebad\app\monitor\include; ..\..\..\component\soc\realtek\amebad\app\xmodem; ..\..\..\component\soc\realtek\amebad\swlib\include; ..\..\..\component\soc\realtek\amebad\swlib\string; ..\..\..\component\soc\realtek\amebad\misc; ..\..\..\component\soc\realtek\amebad\swlib\os_dep\include\; ..\..\..\component\soc\realtek\amebad\swlib\os_dep\..\; ..\..\..\component\soc\realtek\amebad\swlib\string; ..\..\..\component\soc\realtek\amebad\fwlib\usb_otg\include; ..\rtl8721dhp_project\inc; ..\..\..\component\common\api; ..\..\..\component\common\api\platform; ..\..\..\component\common\api\wifi; ..\..\..\component\common\api\network; ..\..\..\component\common\api\network\include; ..\..\..\component\common\audio; ..\..\..\component\common\test; ..\..\..\component\common\example; ..\..\..\component\common\utilities; ..\..\..\component\common\drivers\si; ..\..\..\component\common\audio\haac; ..\..\..\component\common\audio\hmp3; ..\..\..\component\common\audio\fdk-aac; ..\..\..\component\common\audio\libav; ..\..\..\component\common\audio\fdk-aac\libSYS\include; ..\..\..\component\common\drivers\wlan\realtek\include; ..\..\..\component\common\drivers\wlan\realtek\src\hci; ..\..\..\component\common\drivers\wlan\realtek\src\osdep; ..\..\..\component\common\drivers\wlan\realtek\src\hal; ..\..\..\component\common\drivers\wlan\realtek\src\hal\phydm; ..\..\..\component\common\drivers\wlan\realtek\src\hal\rtl8721d; ..\..\..\component\common\drivers\wlan\realtek\src\hal\rtl8721d\little_driver\include; ..\..\..\component\common\drivers\wlan\realtek\wlan_ram_map\rom; ..\..\..\component\common\network; ..\..\..\component\common\network\lwip\lwip_v1.4.1\src\include; ..\..\..\component\common\network\lwip\lwip_v1.4.1\src\include\lwip; ..\..\..\component\common\network\lwip\lwip_v1.4.1\src\include\netif; ..\..\..\component\common\network\lwip\lwip_v1.4.1\src\include\ipv4; ..\..\..\component\common\network\lwip\lwip_v1.4.1\port\realtek; ..\..\..\component\common\network\lwip\lwip_v1.4.1\port\realtek\freertos; ..\..\..\component\common\api; ..\..\..\component\common\api\at_cmd; ..\..\..\component\common\api\wifi\rtw_wpa_supplicant\src; ..\..\..\component\os\os_dep\include\; ..\..\..\component\common\drivers\inic\rtl8721d; ..\..\..\component\common\network\ssl\polarssl-1.3.8\include; ..\..\..\component\common\network\ssl\ssl_ram_map\rom; ..\..\..\component\common\network\ssl\mbedtls-2.4.0\include; ..\..\..\component\common\network\ssl\mbedtls_ram_map\rom; ..\..\..\component\common\mbed\targets\hal\rtl8721d\; ..\..\..\component\common\mbed\targets\hal\rtl8721d\include; ..\mbed_api\mbed\api; ..\mbed_api\mbed\hal; ..\mbed_api\mbed\hal_ext; ..\..\..\component\common\application\baidu\libduer-device\external\mbedtls-port; ..\..\..\component\common\application\apple\WACServer\External\Curve25519; ..\..\..\component\common\application\apple\WACServer\External\GladmanAES; ..\..\..\component\common\application\apple\homekit\crypto\chacha; ..\..\..\component\common\application\apple\homekit\crypto\poly1305; ..\..\..\component\common\application\apple\homekit\crypto\ed25519; ..\..\..\component\common\application\apple\homekit\crypto\ed25519\core; ..\..\..\component\common\application\apple\homekit\crypto\sha512; ..\..\..\component\common\file_system\fatfs\r0.10c\include; ..\..\..\component\common\file_system\fatfs; ..\..\..\component\common\file_system\ftl; ..\..\..\component\common\drivers\usb_class\device; ..\..\..\component\common\drivers\usb_class\device\class; ..\..\..\component\common\application\baidu\libduer-device\framework\core; ..\..\..\component\common\application\baidu\libduer-device\framework\include; ..\..\..\component\common\application\baidu\duerapp\include; ..\..\..\component\common\bluetooth\realtek\sdk\inc\os; ..\..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\gap; ..\..\..\component\common\bluetooth\realtek\sdk\board\amebad\lib; ..\..\..\component\common\bluetooth\realtek\sdk\inc\app; ..\..\..\component\common\bluetooth\realtek\sdk\inc\platform; ..\..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile; ..\..\..\component\common\bluetooth\realtek\sdk\example\ble_central; ..\..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile\client; ..\..\..\component\common\bluetooth\realtek\sdk\board\common\inc; ..\..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile\server; ..\..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile\server; ..\..\..\component\common\bluetooth\realtek\sdk\src\mcu\module\data_uart_cmd; ..\..\..\component\common\bluetooth\realtek\sdk\inc\stack; $TOOLKIT_DIR$\inc\c; ..\..\..\component\common\network\coap\include; ..\..\..\component\common\drivers\sdio\realtek\sdio_host\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\component\os\freertos\freertos_v8.1.2\Source\portable\IAR\ARM_CM4F; ..\rtl8721dhp_project\inc
  OBJCOPY.OOCOutputFile: km4_application.srec
  prebuild: CSCRIPT  "..\..\..\component\soc\realtek\amebad\misc\iar_utility\common\rtl8721d_prebuild.vbs" "$PROJ_DIR$" "..\rtl8721dhp_project"
  postbuild: CSCRIPT  "..\..\..\component\soc\realtek\amebad\misc\iar_utility\common\rtl8721dhp_postbuild_img2.vbs" "$TARGET_DIR$" "$PROJ_DIR$" "$TOOLKIT_DIR$"
  ILINK.IlinkOutputFile: km4_application.axf
  ILINK.IlinkIcfFile: rtl8721dhp_image2.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app/monitor
    ../../../component/soc/realtek/amebad/app/monitor/ram/: low_level_io.c monitor_hp.c rtl_trace.c shell_ram.c
    ../../../component/soc/realtek/amebad/app/monitor/rom/: monitor_rom.c shell_rom.c
  group app/rcu
    ../../../component/soc/realtek/amebad/app/rcu/: rcu_stimuli.c
  group bluetooth
    ../../../component/common/bluetooth/realtek/sdk/example/ble_peripheral/: app_task.c ble_app_main.c peripheral_app.c
    ../../../component/common/bluetooth/realtek/sdk/src/ble/profile/server/: bas.c simple_ble_service.c
    ../../../component/common/bluetooth/realtek/sdk/example/ble_central/: ble_central_app_main.c ble_central_app_task.c ble_central_at_cmd.c ble_central_client_app.c ble_central_link_mgr.c user_cmd.c
    ../../../component/common/bluetooth/realtek/sdk/example/bt_beacon/: bt_beacon_app.c bt_beacon_app_main.c bt_beacon_app_task.c
    ../../../component/common/bluetooth/realtek/sdk/example/bt_config/: bt_config_app_main.c bt_config_app_task.c bt_config_peripheral_app.c bt_config_service.c
    ../../../component/common/bluetooth/realtek/sdk/board/amebad/src/data_uart/: data_uart.c
    ../../../component/common/bluetooth/realtek/sdk/src/ble/profile/client/: gcs_client.c
    ../../../component/common/bluetooth/realtek/sdk/src/mcu/module/data_uart_cmd/: user_cmd_parse.c
  group cmsis-dsp
    ../../../component/soc/realtek/amebad/cmsis-dsp/Source/BasicMathFunctions/: arm_abs_f32.c arm_abs_q15.c arm_abs_q31.c arm_abs_q7.c arm_add_f32.c arm_add_q15.c arm_add_q31.c arm_add_q7.c arm_dot_prod_f32.c arm_dot_prod_q15.c arm_dot_prod_q31.c arm_dot_prod_q7.c arm_mult_f32.c arm_mult_q15.c arm_mult_q31.c arm_mult_q7.c arm_negate_f32.c arm_negate_q15.c arm_negate_q31.c arm_negate_q7.c arm_offset_f32.c arm_offset_q15.c arm_offset_q31.c arm_offset_q7.c arm_scale_f32.c arm_scale_q15.c arm_scale_q31.c arm_scale_q7.c arm_shift_q15.c arm_shift_q31.c arm_shift_q7.c arm_sub_f32.c arm_sub_q15.c arm_sub_q31.c arm_sub_q7.c
    ../../../component/soc/realtek/amebad/cmsis-dsp/Source/TransformFunctions/: arm_bitreversal.c arm_bitreversal2.S arm_cfft_f32.c arm_cfft_q15.c arm_cfft_q31.c arm_cfft_radix2_f32.c arm_cfft_radix2_init_f32.c arm_cfft_radix2_init_q15.c arm_cfft_radix2_init_q31.c arm_cfft_radix2_q15.c arm_cfft_radix2_q31.c arm_cfft_radix4_f32.c arm_cfft_radix4_init_f32.c arm_cfft_radix4_init_q15.c arm_cfft_radix4_init_q31.c arm_cfft_radix4_q15.c arm_cfft_radix4_q31.c arm_cfft_radix8_f32.c arm_dct4_f32.c arm_dct4_init_f32.c arm_dct4_init_q15.c arm_dct4_init_q31.c arm_dct4_q15.c arm_dct4_q31.c arm_rfft_f32.c arm_rfft_fast_f32.c arm_rfft_fast_init_f32.c arm_rfft_init_f32.c arm_rfft_init_q15.c arm_rfft_init_q31.c
    ../../../component/soc/realtek/amebad/cmsis-dsp/Source/ComplexMathFunctions/: arm_cmplx_conj_f32.c arm_cmplx_conj_q15.c arm_cmplx_conj_q31.c arm_cmplx_dot_prod_f32.c arm_cmplx_dot_prod_q15.c arm_cmplx_dot_prod_q31.c arm_cmplx_mag_f32.c arm_cmplx_mag_q15.c arm_cmplx_mag_q31.c arm_cmplx_mag_squared_f32.c arm_cmplx_mag_squared_q15.c arm_cmplx_mag_squared_q31.c arm_cmplx_mult_cmplx_f32.c arm_cmplx_mult_cmplx_q15.c arm_cmplx_mult_cmplx_q31.c arm_cmplx_mult_real_f32.c arm_cmplx_mult_real_q15.c arm_cmplx_mult_real_q31.c
    ../../../component/soc/realtek/amebad/cmsis-dsp/Source/CommonTables/: arm_common_tables.c arm_const_structs.c
    ../../../component/soc/realtek/amebad/cmsis-dsp/Source/FastMathFunctions/: arm_cos_f32.c arm_cos_q15.c arm_cos_q31.c arm_sin_f32.c arm_sin_q15.c arm_sin_q31.c arm_sqrt_q15.c arm_sqrt_q31.c
  group drivers/ir
    ../../../component/common/drivers/ir/protocol/: ir_nec_protocol.c
  group drivers/si
    ../../../component/common/drivers/si/: rl6548.c
  group fwlib
    ../../../component/soc/realtek/amebad/fwlib/ram_common/: rtl8721d_adc.c rtl8721d_bor.c rtl8721d_captouch.c rtl8721d_comparator.c rtl8721d_flash_ram.c rtl8721d_gdma_memcpy.c rtl8721d_i2c.c rtl8721d_ipc_api.c rtl8721d_ir.c rtl8721d_keyscan.c rtl8721d_pll.c rtl8721d_ram_libc.c rtl8721d_rand2.c rtl8721d_rtc.c rtl8721d_sgpio.c rtl8721d_tim.c rtl8721d_uart.c rtl8721d_wdg.c
    ../../../component/soc/realtek/amebad/fwlib/ram_hp/: rtl8721dhp_app_start.c rtl8721dhp_audio.c rtl8721dhp_clk.c rtl8721dhp_cpft.c rtl8721dhp_i2s.c rtl8721dhp_lcdc.c rtl8721dhp_ota_ram.c rtl8721dhp_pmc.c rtl8721dhp_pmc_ram.c rtl8721dhp_psram.c rtl8721dhp_sd.c rtl8721dhp_sdio.c rtl8721dhp_sdio_host.c rtl8721dhp_simulation.c rtl8721dhp_ssi.c rtl8721dhp_startup.c rtl8721dhp_system.c rtl8721dhp_usi_i2c.c rtl8721dhp_usi_ssi.c rtl8721dhp_usi_uart.c
    ../../../component/soc/realtek/amebad/fwlib/crypto/: rtl8721dhp_chacha_poly1305.c rtl8721dhp_md5.c rtl8721dhp_sha.c
  group fwlib/usrcfg
    ../../../component/soc/realtek/amebad/fwlib/usrcfg/: rtl8721d_ipccfg.c rtl8721d_wificfg.c rtl8721dhp_intfcfg.c rtl8721dlp_intfcfg.c
  group lib
    ../../../component/soc/realtek/amebad/misc/bsp/lib/common/IAR/: cmse_implib.a lib_httpc.a lib_httpd.a lib_tftp.a lib_websocket.a lib_wlan.a lib_wps.a
  group mbed
    ../../../component/common/mbed/targets/hal/rtl8721d/: analogin_api.c dma_api.c efuse_api.c flash_api.c gpio_api.c gpio_irq_api.c i2c_api.c i2s_api.c pinmap.c pinmap_common.c port_api.c pwmout_api.c rtc_api.c serial_api.c sleep.c spdio_api.c spi_api.c sys_api.c timer_api.c us_ticker.c us_ticker_api.c wait_api.c wdt_api.c
  group misc
    ../../../component/soc/realtek/amebad/misc/: rtl8721d_freertos_pmu.c rtl8721d_ota.c
  group os/freertos
    ../../../component/os/freertos/: cmsis_os.c freertos_service.c
  group os/freertos/source
    ../../../component/os/freertos/freertos_v8.1.2/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../component/os/freertos/freertos_v8.1.2/Source/portable/MemMang/: heap_5.c
  group os/freertos/source/portable
    ../../../component/os/freertos/freertos_v8.1.2/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group os/os_dep
    ../../../component/os/os_dep/: device_lock.c osdep_service.c psram_reserve.c
  group user
    ../../../component/soc/realtek/amebad/misc/iar_utility/common/tools/: link_dummy.c
    ../rtl8721dhp_project/src/: main.c
  group utilities
    ../../../component/common/utilities/: ssl_client.c ssl_client_ext.c tcptest.c webserver.c
  group utilities/example
    ../../../component/common/example/bcast/: example_bcast.c
    ../../../component/common/example/coap/: example_coap.c
    ../../../component/common/example/competitive_headphones/: example_competitive_headphones.c
    ../../../component/common/example/competitive_headphones_dongle/: example_competitive_headphones_dongle.c
    ../../../component/common/example/eap/: example_eap.c
    ../../../component/common/example/: example_entry.c
    ../../../component/common/example/fatfs/: example_fatfs.c
    ../../../component/common/example/get_beacon_frame/: example_get_beacon_frame.c
    ../../../component/common/example/high_load_memory_use/: example_high_load_memory_use.c
    ../../../component/common/example/http_client/: example_http_client.c
    ../../../component/common/example/http_download/: example_http_download.c
    ../../../component/common/example/httpc/: example_httpc.c
    ../../../component/common/example/httpd/: example_httpd.c
    ../../../component/common/example/mcast/: example_mcast.c
    ../../../component/common/example/mdns/: example_mdns.c
    ../../../component/common/example/mqtt/: example_mqtt.c
    ../../../component/common/example/nonblock_connect/: example_nonblock_connect.c
    ../../../component/common/example/rarp/: example_rarp.c
    ../../../component/common/example/sntp_showtime/: example_sntp_showtime.c
    ../../../component/common/example/socket_select/: example_socket_select.c
    ../../../component/common/example/ssl_download/: example_ssl_download.c
    ../../../component/common/example/ssl_server/: example_ssl_server.c
    ../../../component/common/example/tcp_keepalive/: example_tcp_keepalive.c
    ../../../component/common/example/uart_atcmd/: example_uart_atcmd.c
    ../../../component/common/example/usb_mass_storage/: example_usb_msc.c
    ../../../component/common/example/wifi_mac_monitor/: example_wifi_mac_monitor.c
    ../../../component/common/example/wlan_fast_connect/: example_wlan_fast_connect.c
    ../../../component/common/example/wlan_scenario/: example_wlan_scenario.c
    ../../../component/common/example/websocket_client/: example_wsclient.c
    ../../../component/common/example/xml/: example_xml.c
  group utilities/fatfs
    ../../../component/common/file_system/fatfs/r0.10c/src/option/: ccsbcs.c
    ../../../component/common/file_system/fatfs/r0.10c/src/: diskio.c ff.c
    ../../../component/common/file_system/fatfs/fatfs_ext/src/: ff_driver.c
    ../../../component/common/file_system/fatfs/disk_if/src/: sdcard.c usbdisk.c
  group utilities/ftl
    ../../../component/common/file_system/ftl/: ftl.c
  group wifi/api
    ../../../component/common/api/at_cmd/: atcmd_bt.c atcmd_lwip.c atcmd_mp.c atcmd_mp_ext0.c atcmd_sys.c atcmd_wifi.c log_service.c
    ../../../component/common/api/: lwip_netconf.c wifi_interactive_mode.c
    ../../../component/common/api/network/src/: ping_test.c ttcp.c wlan_network.c
    ../../../component/common/api/wifi/rtw_wpa_supplicant/src/crypto/: tls_polarssl.c
    ../../../component/common/api/wifi/: wifi_conf.c wifi_ind.c wifi_promisc.c wifi_simple_config.c wifi_util.c
    ../../../component/common/api/wifi/rtw_wpa_supplicant/wpa_supplicant/: wifi_eap_config.c wifi_p2p_config.c wifi_wps_config.c
  group wifi/mbedtls
    ../../../component/common/network/ssl/mbedtls-2.4.0/library/: aesni.c blowfish.c camellia.c ccm.c certs.c cipher.c cmac.c debug.c ecp_ram.c entropy.c error.c gcm.c havege.c memory_buffer_alloc.c net_sockets.c padlock.c pkcs11.c pkcs12.c pkcs5.c pkparse.c platform.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c
    ../../../component/common/network/ssl/mbedtls-2.4.0/: mbedtls_rom_test.c
    ../../../component/common/network/ssl/ssl_ram_map/: ssl_ram_map.c
  group wifi/network/sram/lwip/port
    ../../../component/common/network/lwip/lwip_v1.4.1/port/realtek/freertos/: ethernetif.c sys_arch.c
  group wifi/network/sram/lwip/src/api
    ../../../component/common/network/lwip/lwip_v1.4.1/src/api/: api_lib.c api_msg.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group wifi/network/sram/lwip/src/core
    ../../../component/common/network/lwip/lwip_v1.4.1/src/core/: def.c lwip_timers.c mem.c memp.c netif.c pbuf.c raw.c tcp.c tcp_in.c tcp_out.c udp.c
    ../../../component/common/network/lwip/lwip_v1.4.1/src/core/ipv4/: igmp.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group wifi/network/sram/lwip/src/netif
    ../../../component/common/network/lwip/lwip_v1.4.1/src/netif/: etharp.c
  group wifi/network/xip
    ../../../component/common/network/dhcp/: dhcps.c
    ../../../component/common/network/httpc/: httpc_tls.c
    ../../../component/common/network/httpd/: httpd_tls.c
    ../../../component/common/network/coap/: sn_coap_ameba_port.c sn_coap_builder.c sn_coap_header_check.c sn_coap_parser.c sn_coap_protocol.c
    ../../../component/common/network/sntp/: sntp.c
    ../../../component/common/network/websocket/: wsclient_tls.c wsserver_tls.c
  group wifi/network/xip/lwip/api
    ../../../component/common/network/lwip/lwip_v1.4.1/src/core/: init.c
  group wifi/network/xip/lwip/core
    ../../../component/common/network/lwip/lwip_v1.4.1/src/core/ipv4/: autoip.c icmp.c inet.c
    ../../../component/common/network/lwip/lwip_v1.4.1/src/core/: dhcp.c dns.c stats.c sys.c
    ../../../component/common/network/lwip/lwip_v1.4.1/src/api/: err.c
